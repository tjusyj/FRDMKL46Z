# IAR project TWRPI_sLCD_baces.ewp, settings and files
configuration RAM_8KB (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: platinum_baces.out
configuration RAM_16KB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\16KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_4KB (ARM, debug)
  as the first configuration, except:
configuration FLASH_128KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: IAR; BACES; CPU_MKL46Z256VMC4
  ICCARM.CCIncludePath2: ..\..\..\src\projects\TWRPI_sLCD; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\
  ILINK.IlinkOutputFile: platinum_firebird.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_64KB (ARM, debug)
  as the first configuration, except:
configuration FLASH_32KB (ARM, debug)
  as the first configuration, except:
configuration FLASH_256KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: IAR; BACES
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: platinum_firebird.srec
  ILINK.IlinkOutputFile: platinum_firebird.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_32KB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\32KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MKL46Z4.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 256KB_Pflash.icf 32KB_Pflash.icf 32KB_RAM.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: baces.h
  group project
    ../../../src/projects/TWRPI_sLCD/: isr.h TWRPI_sLCD.c
