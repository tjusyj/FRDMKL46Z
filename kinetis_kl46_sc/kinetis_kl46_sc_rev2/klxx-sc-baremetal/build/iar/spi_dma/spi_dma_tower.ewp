# IAR project spi_dma_tower.ewp, settings and files
configuration FLASH_256KB (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER
  ICCARM.CCIncludePath2: ..\..\..\src\projects\spi_dma\dma_spi; ..\..\..\src\projects\spi_dma\spi; ..\..\..\src\projects\spi_dma; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spi_dma_tower.srec
  ILINK.IlinkOutputFile: platinum_firebird.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MKL46Z4.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 256KB_Pflash.icf 32KB_Pflash.icf 32KB_RAM.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: tower.h
  group project
    ../../../src/projects/spi_dma/: isr.h spi_dma.c
  group project/DMA_spi
    ../../../src/projects/spi_dma/DMA_spi/: DMA_spi.c DMA_spi.h
  group project/SPI
    ../../../src/projects/spi_dma/SPI/: SPI.c SPI.h SPI_Control.c SPI_Control.h
